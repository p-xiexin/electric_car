# Keil uVision project Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429_439xx, USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CMSIS;..\FWLIB\inc;..\Startup;..\User;..\User\Hardware;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\User\APP\FreeRTOS_task;..\User\APP\user_task;..\User\Components\controller;..\User\Components\algorithm;..\User\Components\algorithm\Include;..\User\Components\support;..\User\APP\motor_task;..\User\APP\chassis_task;..\User\APP\remote_control;..\User\user_lib;..\User\APP\INS_task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fmc.c
  group Startup
    ../Startup/: startup_stm32f429_439xx.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Hardware
    ../User/Hardware/: delay.c sys.c encoder.c motor.c usart.c rc.c lcd_key_led.c lcd.c user_ui.c pwm.c adc.c jy901.c
  group APP
    ../User/APP/FreeRTOS_task/: FreeRTOS_middleware.c start_task.c
    ../User/APP/user_task/: user_task.c
    ../User/APP/motor_task/: motor_task.c
    ../User/APP/chassis_task/: chassis_task.c
    ../User/APP/remote_control/: remote_control.c
    ../User/Hardware/: lcdfont.c
  group user_lib
    ../User/user_lib/: Kalman_Filter.c user_lib.c
  group controller
    ../User/Components/controller/: pid.c
  group algorithm
    ../User/Components/algorithm/: AHRS_middleware.c arm_cortexM4lf_math.lib AHRS.lib
  group support
    ../User/Components/support/: CRC8_CRC16.c fifo.c
  group USER
    ../User/: main.c
